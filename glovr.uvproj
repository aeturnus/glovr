# Keil uVision project glovr.uvproj, settings and files
target Glove (ARM-ADS)
  device: TM4C1231H6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Glove
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./src/: startup.s GloveMain.c BaseStationMain.c DriverTest.c RF_RXTest.c RF_TXTest.c PCTest.c MPUTest.c
  group Drivers
    ./src/drivers/tm4c/: UART.c PLL.c I2C.c SysTick.c ADC.c
    ../ee445l/mpu-libtest/: I2C0.c
    ./src/drivers/devices/: MPU9250.c
    ./src/drivers/system/: io.c switch.c
  group Devices
    ./src/drivers/devices/: ST7735.c nRF24L01p_mbed.c
  group System
    ./src/drivers/system/: time.c motion.c
target BaseStation (ARM-ADS)
  device: TM4C1231H6PM Texas Instruments
  cpu: as above
  output: BaseStation
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target DriverTest (ARM-ADS)
  device: TM4C1231H6PM Texas Instruments
  cpu: as above
  output: Glove
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target RF_TX_Test (ARM-ADS)
  device: TM4C1231H6PM Texas Instruments
  cpu: as above
  output: Glove
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target RF_RX_Test (ARM-ADS)
  device: TM4C1231H6PM Texas Instruments
  cpu: as above
  output: Glove
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target PCTest (ARM-ADS)
  device: TM4C1231H6PM Texas Instruments
  cpu: as above
  output: Glove
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target MPUTest (ARM-ADS)
  device: TM4C1231H6PM Texas Instruments
  cpu: as above
  output: Glove
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
